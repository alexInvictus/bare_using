# Keil uVision project usart.uvprojx, settings and files
target usart (ARM-ADS)
  device: STM32F429IG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: usart +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx
  c misc: --C99
  c include: ../Inc;  ../Drivers/STM32F4xx_HAL_Driver/Inc;  ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;  ../Drivers/CMSIS/Include;  ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;  .\System\delay;  .\System\sys;  .\usart;  ..\wave-iic\ks103;  ..\wave-iic\myiic;  .\pwm;  ..\MDK-ARM;  .\24c02;  .\lcd
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Drivers/CMSIS
    ../Drivers/CMSIS//Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group System
    ./System/delay/: delay.c
    ./System/sys/: sys.c
    ./usart/: usart.c
  group wave-iic
    ../wave-iic/ks103/: ks103.c
    ../wave-iic/myiic/: myiic2.c
  group init
    ./init/: uart_init.c pwm.c gpio_init.c sysclock.c adc_dma.c
  group eeprom
    ./eeprom/: eeprom.c
  group motor
    ./motor/: motor.c
  group 24c02
    ./24c02/: 24cxx.c myiic.c
  group LCD
    ./lcd/: LCD_Driver.c
  group Application/MDK-ARM
    ./: startup_stm32f429xx.s
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_dma.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal.c stm32f4xx_hal_flash.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_pwr.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_uart.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_tim.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c
  group Application/User
    ../Src/: stm32f4xx_it.c stm32f4xx_hal_msp.c main.c
software components: CMSIS:CORE 3.40.0
